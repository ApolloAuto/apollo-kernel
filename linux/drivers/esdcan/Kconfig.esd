## linux/drivers/esdcan/Kconfig.esd
```kconfig
config ESDCAN
    tristate "ESD CAN-driver"
    ---help---
      Esd's new CAN-driver.
```
